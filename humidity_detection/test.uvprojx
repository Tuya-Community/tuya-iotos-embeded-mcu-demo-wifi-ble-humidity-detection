# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00009000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32G0xx\Include;.\CMSIS\Include;.\sys;.\User;.\mcu_sdk
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group CMSIS
    ./CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
    ./CMSIS/Device/ST/STM32G0xx/Source/Templates/arm/: startup_stm32g071xx.s
  group User
    ./User/: main.c README.c MY_ST_config.h
  group System
    ./sys/: sys.c RCC.c IO.c delay.c TIM.c USART.c
  group Tuya
    ./mcu_sdk/: mcu_api.c protocol.c system.c
